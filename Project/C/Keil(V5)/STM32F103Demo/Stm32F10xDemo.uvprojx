# Keil uVision project Stm32F10xDemo.uvprojx, settings and files
target STM32F103Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32F10xDemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c misc: --diag_suppress=1296
  c include: ..\..\..\..\Src\C\Common\System;..\..\..\..\Src\C\Stm32F103Demo;..\..\..\..\ThirdParty\FreeRTOSv8.0.1\inc;..\..\..\..\Src\C\Common\EmbedDriver\F10xStdPeriph;..\..\..\..\Src\C\Common\Lang;..\..\..\..\Src\C\Common\EmbedDriver\MSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Stm32F103Demo
    ../../../../Src/C/Stm32F103Demo/: Event.c BSP.c
  group Common/System
    ../../../../Src/C/Common/System/: main.c stm32f10x_it.c
  group Common/EmbedDriver
    ../../../../Src/C/Common/EmbedDriver/F10xStdPeriph/: Gpio.c Usart.c Dma.c
    ../../../../Src/C/Common/EmbedDriver/MSP/: MspSTM32F103RCT6.c
  group ThirdParty/FreeRTOS
    ../../../../ThirdParty/FreeRTOSv8.0.1/src/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOSv8.0.1/inc/: FreeRTOSConfig.h
  group Common/Lang
    ../../../../Src/C/Common/Lang/: CExpection.c
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
